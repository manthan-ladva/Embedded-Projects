# Keil uVision project 9999_forward_reverse.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 9999_forward_reverse +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 9999_forward_and_reverse.c

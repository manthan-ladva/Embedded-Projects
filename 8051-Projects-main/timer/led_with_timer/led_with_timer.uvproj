# Keil uVision project led_with_timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: led_with_timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led_with_timer.c

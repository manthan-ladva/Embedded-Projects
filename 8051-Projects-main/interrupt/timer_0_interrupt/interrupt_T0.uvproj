# Keil uVision project interrupt_T0.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: interrupt_T0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: interrpt_t0.c
